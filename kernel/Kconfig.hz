## kernel/Kconfig.hz
```kconfig
#
# Timer Interrupt Frequency Configuration
#

config HZ
	int "How many interrupts per second"
	default 250

config SCHED_HRTICK
	def_bool HIGH_RES_TIMERS
```
